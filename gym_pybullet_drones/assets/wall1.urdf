Commit message: here

File: gym_pybullet_drones/assets/wall1.urdf (robot description, URDF)
Before this commit: robot vertical_board, 1 links, 0 joints
Links:
- link board_link: geometry collision box size=0.05 0.5 2; visual box size=0.05 0.5 2
